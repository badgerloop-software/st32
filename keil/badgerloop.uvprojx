# Keil uVision project badgerloop.uvprojx, settings and files
target Nucleo144-STM32F767ZI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: badgerloop
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group src
    ../src/: main.c nuc144.c
  group src/driver
    ../src/driver/: gpio.c rcc.c timer.c usart.c
  group src/system
    ../src/system/: startup_stm32f767xx.s system_stm32f7xx.c
  group include
    ../include/: config.h main.h nuc144.h
  group include/driver
    ../include/driver/: gpio.h rcc.h timer.h usart.h
  group include/device
    ../include/device/: cmsis_armcc.h cmsis_compiler.h core_cm7.h stm32f7xx.h stm32f767xx.h system_stm32f7xx.h
